
# 170506 currently do not want 'tk'...
RDEPENDS_${PN} = ""

