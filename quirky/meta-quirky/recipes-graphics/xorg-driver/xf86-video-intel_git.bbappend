#need the older uxa video acceleration. this will be enabled in addition to sna
PACKAGECONFIG_append = " uxa"
