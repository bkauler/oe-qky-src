
# BK 170614 have introduced new dep
DEPENDS += "libgd"
