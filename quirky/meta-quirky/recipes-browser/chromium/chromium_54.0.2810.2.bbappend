
# 170505 remove 'pulseaudio', change 'libav' to 'ffmpeg'...
DEPENDS = "xz-native pciutils cairo nss zlib-native ffmpeg cups ninja-native gconf libexif pango libdrm libgnome-keyring gperf-native xextproto gtk+ libxi libxss"

#***NOT WORKING, WANTS pulseaudio***
