
# BK 20171023 my harfbuzz recipe has graphite2 dep, wants graphite2-native.
# um, will this do it...
BBCLASSEXTEND = "native"
