
RPROVIDES_${PN} = "libsoup"
DEPENDS += "glib-networking"
